# Keil uVision project 09_iic_software.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 01_led_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\start;.\user;.\driver;.\interface;.\application;.\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group start
    ./start/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group user
    ./user/: main.c
  group driver
    ./driver/: dri_led.c dri_key.c dri_uart.c dri_iic.c dri_iic.h dri_key.h dri_led.h dri_uart.h
  group interface
    ./interface/: inf_led.c inf_key.c inf_w24c02.c inf_key.h inf_led.h inf_w24c02.h
  group common
    ./common/: common_delay.c
