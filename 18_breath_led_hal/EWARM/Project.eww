<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\18_breath_led_hal.ewp</path>
  </project>
  <batchBuild />
</workspace>
